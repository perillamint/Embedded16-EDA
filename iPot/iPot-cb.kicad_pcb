# Repository perillamint/Embedded16-EDA

## KiCad design iPot/iPot-cb.kicad_pcb

Parts:
C1: 100u; C_Radial_D10_L13_P5
C2: 0.1u; C_Disc_D6_P5
C3: 3.3n; C_Disc_D3_P2.5
C4: 100nF; C_Disc_D6_P5
C5, C6: 15pF; C_Disc_D3_P2.5
C7: 10u; C_Radial_D10_L20_P2.5
CON1: 12VDC; BARREL_JACK
D1: 1N914; Diode_DO-35_SOD27_Horizontal_RM10
D2: 1N5818; Diode_DO-41_SOD81_Horizontal_RM10
D3, D4, D5, D6, D7, D8, D9, D10: 1N4148; Diode_DO-35_SOD27_Horizontal_RM10
HS1: HEATSINK; SY403B
IC1: ATMEGA644-P; DIP-40_W15.24mm
IC2: L298; Multiwatt_15_Vertical
JP1: ISP_SELECT_JP; Pin_Header_Straight_1x03
L1: 20u; Choke_Toroid_5x10mm_Vertical
P1: MOT2; TerminalBlock_Pheonix_MKDS1.5-2pol
P2: MOT1; TerminalBlock_Pheonix_MKDS1.5-2pol
P3: INT0; Pin_Header_Straight_1x03
P4: INT1; Pin_Header_Straight_1x03
P5: USB_PWR1; USB_A_Vertical
P6: JTAG; Pin_Header_Straight_2x05
P7: SPI; Pin_Header_Straight_2x03
P8: I2C1; Pin_Header_Straight_1x04
P9: I2C2; Pin_Header_Straight_1x04
P10: I2C3; Pin_Header_Straight_1x04
P11: I2C4; Pin_Header_Straight_1x04
P12: UART; Pin_Header_Straight_1x03
P13: USB_PWR2; USB_A_Vertical
P14: ANALOG_IN; Pin_Header_Straight_1x11
P15: PWM_IO; Pin_Header_Straight_1x04
Q1, Q4, Q5, Q6: 2SC1815; TO-92_Inline_Wide
Q2, Q3: IRF9610; TO-220_Neutral123_Vertical
R1, R2: 1k; Resistor_Horizontal_RM10mm
R3, R6, R9, R10, R11: 4.7k; Resistor_Horizontal_RM10mm
R4, R5, R12, R13: 10k; Resistor_Horizontal_RM10mm
R7: 390; Resistor_Horizontal_RM10mm
R8: 680; Resistor_Horizontal_RM10mm
SW1: RESET_SW; SW_PUSH_SMALL
U1: LM317AT; TO-220_Neutral123_Vertical
U2: LT1376; DIP-8_W7.62mm
Y1: 10MHz; Crystal_HC49-U_Vertical

Connections:
+5V: C1.1, D1.2 (A), IC2.9, L1.1, P3.1, P4.1, P14.1, Q2.3 (S), Q3.3 (S), R4.1, R5.1, U1.3 (IN), U2.4 (BIAS), U2.7 (FBSENSE)
+12V: C7.1, CON1.1, D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), IC2.4, U2.2 (V_IN)
//SS: IC1.5 ((PCINT12/OC0B/~SS~)PB4), JP1.1
/MISO: IC1.7 ((PCINT14/MISO)PB6), P7.1
/MOSI: IC1.6 ((PCINT13/MOSI)PB5), P7.4
/MOT1F: IC1.1 ((PCINT8/T0/XCK)PB0), IC2.5
/MOT1PWM: IC1.18 ((PCINT28/OC1B)PD4), IC2.6
/MOT1R: IC1.2 ((PCINT9/CLKO/T1)PB1), IC2.7
/MOT2F: IC1.3 ((PCINT10/AIN0/INT2)PB2), IC2.10
/MOT2PWM: IC1.19 ((PCINT294/OC1A)PD5), IC2.11
/MOT2R: IC1.4 ((PCINT11/AIN1/OC0A)PB3), IC2.12
/RST: C4.1, IC1.9 (~RESET), JP1.3, P6.6, R11.2, SW1.2
/RXD: IC1.14 ((PCINT24/RXD0)PD0), P12.1
/SCK: IC1.8 ((PCINT15/SCK)PB7), P7.3
/SCL: IC1.22 ((PCINT16/SCL)PC0), P8.4, P9.4, P10.4, P11.4, R12.2
/SDA: IC1.23 ((PCINT17/SDA)PC1), P8.3, P9.3, P10.3, P11.3, R13.2
/TCK: IC1.24 ((PCINT18/TCK)PC2), P6.1
/TDI: IC1.27 ((PCINT21/TDI)PC5), P6.9
/TDO: IC1.26 ((PCINT20/TDO)PC4), P6.3
/TMS: IC1.25 ((PCINT19/TMS)PC3), P6.5
/TXD: IC1.15 ((PCINT25/TXD0)PD1), P12.2
/USB1: IC1.28 ((PCINT22/TOSC1)PC6), R9.2
/USB2: IC1.29 ((PCINT23/TOSC2)PC7), R10.2
/WSENS1: IC1.16 ((PCINT26/INT0)PD2), Q6.2 (C), R6.2
/WSENS2: IC1.17 ((PCINT27/INT1)PD3), Q1.2 (C), R3.2
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, CON1.2, CON1.3, D2.2, D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), IC1.11 (GND), IC1.31 (GND), IC2.1, IC2.8, IC2.15, P3.3, P4.3, P5.4 (GND), P5.5 (shield), P6.2, P6.10, P7.6, P8.2, P9.2, P10.2, P11.2, P12.3, P13.4 (GND), P13.5 (shield), P14.11, P15.4, Q1.1 (E), Q4.1 (E), Q5.1 (E), Q6.1 (E), R8.2, SW1.1, U2.6 (GND)
unnamed: C2.1, D1.1 (K), U2.1 (BOOST)
unnamed: C2.2, D2.1, L1.2, U2.3 (V_SW)
unnamed: C3.1, U2.8 (V_C)
unnamed: C5.1, IC1.12 (XTAL2), Y1.1
unnamed: C6.1, IC1.13 (XTAL1), Y1.2
unnamed: D3.1 (K), D7.2 (A), IC2.3, P2.2
unnamed: D4.1 (K), D8.2 (A), IC2.2, P2.1
unnamed: D5.1 (K), D9.2 (A), IC2.14, P1.2
unnamed: D6.1 (K), D10.2 (A), IC2.13, P1.1
unnamed: IC1.20 ((PCINT30/OC2B/ICP)PD6), P15.2
unnamed: IC1.21 ((PCINT31/OC2A)PD7), P15.3
unnamed: IC1.33 ((PCINT7/ADC7)PA7), P14.10
unnamed: IC1.34 ((PCINT6/ADC6)PA6), P14.9
unnamed: IC1.35 ((PCINT5/ADC5)PA5), P14.8
unnamed: IC1.36 ((PCINT4/ADC4)PA4), P14.7
unnamed: IC1.37 ((PCINT3/ADC3)PA3), P14.6
unnamed: IC1.38 ((PCINT2/ADC2)PA2), P14.5
unnamed: IC1.39 ((PCINT1/ADC1)PA1), P14.4
unnamed: IC1.40 ((PCINT0/ADC0)PA0), P14.3
unnamed: JP1.2, P7.5
unnamed: P3.2, R1.2
unnamed: P4.2, R2.2
unnamed: P5.1 (VCC), Q2.2 (D)
unnamed: P13.1 (VCC), Q3.2 (D)
unnamed: Q1.3 (B), R2.1
unnamed: Q2.1 (G), Q4.2 (C), R5.2
unnamed: Q3.1 (G), Q5.2 (C), R4.2
unnamed: Q4.3 (B), R9.1
unnamed: Q5.3 (B), R10.1
unnamed: Q6.3 (B), R1.1
unnamed: R7.2, R8.1, U1.1 (ADJ)

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
Board: 2 copper layers, 100.0 x 100.0 mm, 66 parts (0 on the bottom side), 58 nets.

Other parts of the board:
MHOLE1, MHOLE2, MHOLE3, MHOLE4: MountingHole_3mm
OSHW_LOGO: Symbol_OSHW-Logo_CopperTop_BIG

## Commit log

2016-05-02 CERN OHL v1.2
2016-05-03 iPot project
2016-05-03 Complete circuit with TR placeholder.
    TODO: Need to find correct TRs.
2016-05-03 Remove old project file
2016-05-03 Add resistor label
2016-05-03 LT1376 part lib
2016-05-03 Draw some power regulators (WIP), Assign some footprint
2016-05-03 Fix MOSFET driver
2016-05-03 Design draft complete
2016-05-04 Add annotation
2016-05-04 l298 library
2016-05-04 Little bit of general purpose design
2016-05-04 bom2csv.xsl file
2016-05-04 Footprint edit
2016-05-04 Update gitignore
2016-05-04 Finalized version 1.0
2016-05-04 Modify gitignore
2016-05-04 Fix connector orientation
2016-05-05 Add autoroute result. (TODO: Copper pour on GND)
2016-05-05 Finalized layout
2016-05-10 Fix MOSFET part No.
2016-05-15 Fix possible problems, bump version 1.1
2016-05-30 Add heatsink
2016-06-08 Fix bug in silk, fix resistor value, bump version to 1.2
2016-06-09 Fix diode footprint
2018-01-16 Include cache files again
2018-01-16 Add cache file

Notices in the files:
iPot/iPot-cb.kicad_pcb:
Licensed under CERN OHL v1.2
released under CERN OHL v1.2 or later.
